# Keil uVision project test.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\cmsis;..\fwlib\inc;..\mylib;..\user
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group cmsis
    ../cmsis/: core_cm3.c startup_stm32f10x_md.s
  group fwlib
    ../fwlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_bkp.c
  group mylib
    ../mylib/: buzzer.c led.c button.c delay.c eint.c iwdg.c usart1.c dht.c oled.c gpio_iic.c eeprom.c sht.c adj_res.c rtc.c ldt.c nrf24l01.c
  group user
    ../user/: main.c stm32f10x_it.c system_stm32f10x.c
